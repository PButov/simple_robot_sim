Commit message: Lidar sensor added

File: urdf/simple_robot_v2.xacro (robot description, xacro)
@@ -114,5 +114,5 @@
   <parent link="base_link"/>
   <child link="right_wheel_1"/>
-  <axis xyz="0.0 -1.0 0.0"/>
+  <axis xyz="0.0 1.0 0.0"/>
 </joint>
 <joint name="Rigid 11" type="fixed">
